# Keil uVision project usb-mouse.uvprojx, settings and files
target Dev board (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: usb-mouse
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\FreeRTOS\Inc;.\Clock\Inc;.\USB\Inc;.\UART\Inc;.\GPIO\Inc;.\LCD\Inc;.\Touch\Inc;.\IIC\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Main
    ./: main.c heartbeat.c
  group FreeRTOS
    ./FreeRTOS/: heap_2.c list.c port.c queue.c tasks.c timers.c
  group Clock
    ./Clock/: clock_config.c fsl_clock.c fsl_common.c
  group USB
    ./USB/: usb_desc.c usb_dev.c usb_mem.c usb_mouse.c
  group UART
    ./UART/: uart.c
  group GPIO
    ./GPIO/: gpio.c
  group LCD
    ./LCD/: lcd.c
  group Touch
    ./Touch/: touch.c
  group IIC
    ./IIC/: iic.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
